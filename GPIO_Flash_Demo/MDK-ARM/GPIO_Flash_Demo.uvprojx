# Keil uVision project GPIO_Flash_Demo.uvprojx, settings and files
target GPIO_Flash_Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPIO_Flash_Demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F411xE
  c misc: --C99
  c include: ..\..\GPIO_Flash_Demo;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../: main.c stm32f4xx_it.c
  group STM32F4xx_StdPriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c
  group CMSIS
    ../: system_stm32f4xx.c
  group MDK-ARM
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f411xe.s
